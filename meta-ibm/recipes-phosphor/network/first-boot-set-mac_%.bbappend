SYSTEMD_SERVICE:${PN}:append:mowgli = " first-boot-set-mac@eth0.service"