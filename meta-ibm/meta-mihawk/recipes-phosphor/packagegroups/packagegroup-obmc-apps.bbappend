RDEPENDS_${PN}-inventory += "openpower-fru-vpd openpower-occ-control phosphor-cooling-type virtual/obmc-gpio-presence id-button"
RDEPENDS_${PN}-extras += "phosphor-webui phosphor-image-signing "

