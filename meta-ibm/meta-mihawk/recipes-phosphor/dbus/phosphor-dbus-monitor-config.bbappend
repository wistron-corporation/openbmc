PHOSPHOR_DBUS_MONITOR_CONFIGS_append = " thermal-policy"
PHOSPHOR_DBUS_MONITOR_CONFIGS_append = " fan-policy"
PHOSPHOR_DBUS_MONITOR_CONFIGS_append = " mihawk-power-supply-policy"